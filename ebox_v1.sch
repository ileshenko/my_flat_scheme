File: ebox_v1.sch (EAGLE design)
At the start: 0 parts

Commit message: EBOX: wip
Other:
- note added: "3x6mm2"
- note added: "N 10mm2"
